# Keil uVision project modbus_rtu_project.uvprojx, settings and files
target Program (6190000::V6.19::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: modbus_master_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./: Main.h Main.c
  group Library
    ./: gpio.c modbus_rtu.c systick.c gpio.h modbus_rtu.h systick.h usart.h usart.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
