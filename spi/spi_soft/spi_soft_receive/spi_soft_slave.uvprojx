# Keil uVision project spi_soft_slave.uvprojx, settings and files
target Program (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: spi_soft_slave +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Main
    ./: main.h main.c
  group Library
    ./: gpio.c gpio.h port.h systick.h systick.c spi_soft.h spi_soft.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
