# Keil uVision project Enc28j60_spi.uvprojx, settings and files
target program (6190000::V6.19::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Enc28j60_spi +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./: main.h main.c
  group library
    ./: enc28j60_spi.h enc28j60_spi.c gpio.h spi.h systick.h gpio.c spi.c systick.c NET.h NET.c ARP.h ARP.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
