# Keil uVision project Lis3dsh_spi_project.uvprojx, settings and files
target program (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lis3dsh_spi_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./: main.h main.c
  group library
    ./: Lis3dsh_spi.h Lis3dsh_spi.c gpio.h spi.h systick.h gpio.c spi.c systick.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
