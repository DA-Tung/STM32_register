# Keil uVision project timer_IC_project.uvprojx, settings and files
target program (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: timer_input_capture +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group file
    ./: main.h main.c
  group library
    ./: gpio.c systick.c gpio.h systick.h timer_input_capture.h timer_input_capture.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
